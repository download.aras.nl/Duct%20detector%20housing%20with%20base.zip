Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2022-11-04T10:49:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 04 10:49:05 2022 * Host: LIS-C-00085 * Database: C:\Users\JAL1OVR\AppData\Local\Temp\{3A2F8377-0529-4D11-B947-0C036FADA386}\ifc * Database version: 5507 * Database creation date: Fri Nov 04 10:49:05 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 04 10:49:05 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 04 10:49:05 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Ebene
Graphics(Type) - Color: 16711680; Line Pattern: Verdeckt; Line Weight: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 m
Dimensions - Computation Height: 0 m
Identity Data - Building Story: yes; Name: Ebene 0; Structural: no
Other - Category: Levels; Family: Level: Ebene; Family and Type: Level: Ebene; Type: Level: Ebene; Type Id: Level: Ebene

# IfcDistributionControlElement: Smoke Detector, Fire-Products_Bosch_Duct_detector_housing_with_base:FAD-420-HS-EN_Duct_detctor_housing_with_base:405973
In: Ebene 0
Type - PredefinedType: SMOKESENSOR; Classification: Pr_75_80_30_22 Duct smoke detectors (Uniclass 2015); Material: Bosch_Grey
Type - Constraints - Commercial Type Number: FAD-420-HS-EN; Default Elevation: 2.1 m
Type - Identity Data - CTN: FAD-420-HS-EN; Description: Air sampling housing with connection board and detector base for Bosch FAD-425-O-R optical smoke detector head. Use in ventilation systems with air velocities from 1 m/s to 20 m/s.; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/FAD_420_HS_EN_Installation_Manual_all_1283878923.pdf; Manufacturer: Bosch Security and Safety Systems; OmniClass Number: 23.85.30.21.11.11; OmniClass Title: Fire/Smoke Detectors; PlanningTools: https://media.boschsecurity.com/fs/media/pb/media/support_1/tools/safety-systems-designer.zip; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/FAD_420_HS_EN_Data_sheet_enUS_87245436939.pdf; Product Website: https://commerce.boschsecurity.com/nlexp/en/Duct-detector-housing-with-base/p/F.01U.029.411/; Type Name: FAD-420-HS-EN_Duct_detctor_housing_with_base
Type - Other - Category: Fire Alarm Devices; Color: Lower part: grey; upper part: transparent; Dimension (H x W x D) in mm: 165 x 395 x 110 mm; Family Name: Fire-Products_Bosch_Duct_detector_housing_with_base; IP rating: IP65; Material: Lower part: Plastic fiber reinforced PPE + PS (UL94-V1); upper part: Plastic PC (UL94-V2); Operating temperature (°C): 0 – 50 °C; Operating voltage (VDC): 15 to 33 VDC; Weight (g): 1500g
Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation: 0 m; Host: Level : Ebene 0; Level: Level: Ebene 0
Dimensions - Area: 0.126775 m2; Volume: 0.00716925 m3
Identity Data - Mark: 4
Other - Family: Fire-Products_Bosch_Duct_detector_housing_with_base: FAD-420-HS-EN_Duct_detctor_housing_with_base; Family and Type: Fire-Products_Bosch_Duct_detector_housing_with_base: FAD-420-HS-EN_Duct_detctor_housing_with_base; Schedule Level: Level: Ebene 0; Type: Fire-Products_Bosch_Duct_detector_housing_with_base: FAD-420-HS-EN_Duct_detctor_housing_with_base; Type Id: Fire-Products_Bosch_Duct_detector_housing_with_base: FAD-420-HS-EN_Duct_detctor_housing_with_base
Phasing - Phase Created: Phase 1
